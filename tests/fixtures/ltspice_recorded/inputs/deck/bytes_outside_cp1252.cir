* Åa çb èc êd ùe Äf ìg
V1 a 0 1
R1 a b 1k
R2 b 0 1k
.op
.end
